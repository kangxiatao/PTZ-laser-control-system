# Keil uVision project ONE.uvprojx, settings and files
target NO_BUG (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SYSTEMS +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\h_files;..\System\clock;..\System\sys;..\System\usart;..\System;..\Hardware\h_files;..\FWlib\inc;..\Control\h_files;..\User_epic;..\Hardware\Touch
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User_epic
    ./c_files/: main.c timer.c pwm.c myusart.c show.c mygui.c queue.c malloc.c
    ./h_files/: include.h
  group Hardware
    ../Hardware/c_files/: key.c led.c lcd.c ahrs.c 24cxx.c w25qxx.c mpuiic.c mpu6050.c inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./c_files/: spi.c myiic.c
    ../Hardware/Touch/: touch.c ctiic.c ft5206.c gt9147.c ott2001a.c
  group System
    ../System/clock/: clock.c
    ../System/sys/: sys.c
    ../System/usart/: usart.c
    ../System/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_pwr.c stm32f10x_spi.c stm32f10x_fsmc.c
  group Control
    ../Control/c_files/: control.c
    ../Control/h_files/: control.h
